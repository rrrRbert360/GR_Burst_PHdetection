options:
  parameters:
    author: PA0BRT
    category: Custom
    comment: |-
      This flowgrapgh generates a 200ms burst of 500Hz.
      After each burst an additional phase shift can generated by setting the "ShiftSteps"
    description: Simulation of burst incl phase shift
    generate_options: qt_gui
    id: top_block
    output_language: python
    title: Burst phase measuring
  states: {}

blocks:
- name: DegreeAngleMultiplier
  id: variable
  parameters:
    value: '57.29577958'
  states: {}
- name: Input_SigIntdelay
  id: variable_qtgui_range
  parameters:
    label: 'Input: Delay SigInt'
    rangeType: int
    start: '0'
    step: '1'
    stop: '1000'
    value: '128'
  states: {}
- name: Input_SignalNoise
  id: variable_qtgui_range
  parameters:
    label: 'Input: Signal-Noise ratio'
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0.66'
  states: {}
- name: ShiftSteps
  id: variable
  parameters:
    comment: |-
      After each burst an additional shift can be defined.
      This results in a situation that each following burst has an incremented shift in relation to the reference clock.
    value: '30'
  states: {}
- name: SquelchThreshold
  id: variable_qtgui_range
  parameters:
    label: 'Input: squelch threshold'
    start: '-20'
    step: '0.1'
    stop: '0'
    value: '-2.7'
  states: {}
- name: pi
  id: variable
  parameters:
    value: '3.1416'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1024e3/4
  states: {}
- name: analog_noise_source_x_0_0
  id: analog_noise_source_x
  parameters:
    amp: Input_SignalNoise
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {}
- name: analog_pwr_squelch_xx_0_0_0
  id: analog_pwr_squelch_xx
  parameters:
    alpha: '1e-4'
    gate: 'False'
    ramp: '0'
    threshold: SquelchThreshold
    type: complex
  states: {}
- name: analog_sig_source_x_0_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '500'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '16000'
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: pi
    type: float
  states: {}
- name: blocks_add_xx_0_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_complex_to_arg_0
  id: blocks_complex_to_arg
  parameters: {}
  states: {}
- name: blocks_complex_to_arg_0_1
  id: blocks_complex_to_arg
  parameters: {}
  states: {state: disabled}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: Input_SigIntdelay
    type: complex
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_moving_average_xx_0_0
  id: blocks_moving_average_xx
  parameters:
    length: '38400'
    max_iter: '4000'
    scale: 1/38400
    type: complex
  states: {}
- name: blocks_multiply_conjugate_cc_0
  id: blocks_multiply_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 1-Input_SignalNoise
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: DegreeAngleMultiplier
    type: float
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_0_2
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_probe_rate_0
  id: blocks_probe_rate
  parameters:
    alpha: '0.15'
    mintime: '500.0'
    type: float
  states: {state: disabled}
- name: blocks_tag_debug_0_0
  id: blocks_tag_debug
  parameters:
    type: float
  states: {state: disabled}
- name: blocks_throttle2_0_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    Shift: ShiftSteps
    _source_code: |
      import numpy as np
      from gnuradio import gr

      class blk(gr.sync_block):
          """
          500 Hz burst generator/selector with accumulating phase shift:
          - Input: complex 500 Hz sine (continuous)
          - Output: 200 ms complex 500 Hz burst every 2 s
          - Burst k has phase offset k * Shift (degrees) w.r.t. input
          """

          def __init__(self, Shift=0.0, samp_rate=256000.0):
              gr.sync_block.__init__(
                  self,
                  name='BurstPhaseShift500Hz_accum',
                  in_sig=[np.complex64],
                  out_sig=[np.complex64],
              )

              self.samp_rate = float(samp_rate)
              self.set_Shift(Shift)

              # Timing
              self.period_s = 2.0
              self.burst_len_s = 0.2
              self.period_samples = int(round(self.period_s * self.samp_rate))
              self.burst_samples = int(round(self.burst_len_s * self.samp_rate))

              # State
              self.sample_index = 0              # global sample counter
              self.burst_index = 0               # which burst (0,1,2,...)
              self.burst_phase_factor = 1+0j     # updated per burst

          def set_Shift(self, Shift):
              """
              Shift is the per‑burst phase increment in degrees.
              Burst k will be rotated by k * Shift degrees.
              """
              Shift = float(Shift) % 360.0
              self.Shift = Shift
              self.Shift_rad = np.deg2rad(self.Shift)

          def work(self, input_items, output_items):
              inp = input_items[0]
              out = output_items[0]

              n = len(out)
              out[:] = 0+0j

              idx = 0
              while idx < n:
                  pos = self.sample_index % self.period_samples

                  if pos < self.burst_samples:
                      # Inside burst window
                      burst_remaining = self.burst_samples - pos
                      to_copy = min(burst_remaining, n - idx)

                      # If this is the FIRST sample of a burst in this call,
                      # update the phase factor for this burst.
                      if pos == 0:
                          # Accumulated phase for this burst:
                          # burst 0 -> 0 * Shift, burst 1 -> 1 * Shift, etc.
                          total_phase = self.burst_index * self.Shift_rad
                          self.burst_phase_factor = np.exp(1j * total_phase).astype(np.complex64)

                          # Increment burst counter for next burst
                          self.burst_index += 1

                      # Apply phase rotation for this burst
                      out[idx:idx+to_copy] = inp[idx:idx+to_copy] * self.burst_phase_factor

                  else:
                      # Outside burst: keep zeros
                      to_copy = min(self.period_samples - pos, n - idx)

                  idx += to_copy
                  self.sample_index += to_copy

              return n
    comment: |-
      Based on a reference CLK and 256k rate, this block generates a 200ms
      burst of 500Hz.
      The burst occur every 2s.
      With every burst an incrimental phase shift can be set.
      e.g. when entering 36 degrees after 10 burst a complete
      phase shift cycle has been reached. 
      when set to 0 the block does not generate any phase shift.
    samp_rate: '256000'
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    Length: '40000'
    _source_code: |-
      #!/usr/bin/env python3
      # -*- coding: utf-8 -*-
      #
      # GNURadio Python Block: Squelch Switch (variable-rate output)
      #
      # - 1 complex input stream
      # - 2 complex output streams
      #
      # Default behavior:
      #   Output[0] receives the input stream (pass-through)
      #   Output[1] produces NO samples at all (stream is truly gated)
      #
      # On tag with key "squelch_sob":
      #   Output[0] produces NO samples (stream is truly gated)
      #   Output[1] receives the input stream
      #   After "Length" samples have been sent to Output[1],
      #   switch back to default behavior.

      import numpy as np
      from gnuradio import gr
      import pmt


      class squelch_switch(gr.basic_block):
          """
          Squelch Switch Block (variable-rate output)

          Routes a complex input stream to one of two complex output streams.
          The inactive output port produces ZERO samples — the IQ stream is
          truly stopped, not just zeroed out.

          Default state:
            - Output[0]: receives all input samples
            - Output[1]: produces no samples at all

          On receiving a tag with key "squelch_sob" on the input stream:
            - Output[0]: produces no samples at all
            - Output[1]: receives input samples for 'Length' samples
            - After 'Length' samples, switches back to default state

          A new "squelch_sob" tag received while already in switched state
          resets the sample counter to 'Length'.

          Parameters
          ----------
          Length : float
              Number of samples to route to Output[1] after a squelch_sob tag.
              Internally cast to int.
          """

          def __init__(self, Length=1024.0):
              gr.basic_block.__init__(
                  self,
                  name="Squelch Switch",
                  in_sig=[np.complex64],
                  out_sig=[np.complex64, np.complex64]
              )

              self.Length = float(Length)

              # Internal state
              self._switched = False        # True  -> route to output[1]
              self._samples_remaining = 0   # samples left to send to output[1]

              self.set_tag_propagation_policy(gr.TPP_DONT)

              # Tell the scheduler the minimum input needed per call.
              # Do NOT override forecast() — in GNURadio 3.10+ the Python gateway
              # passes ninput_items_required as a bare int, making it impossible to
              # assign to it correctly from Python. Using set_min_noutput_items(1)
              # ensures the scheduler always gives us at least 1 sample to work with.
              self.set_min_noutput_items(1)

          # ------------------------------------------------------------------
          # Properties for GRC
          # ------------------------------------------------------------------
          def get_Length(self):
              return self.Length

          def set_Length(self, Length):
              self.Length = float(Length)

          # ------------------------------------------------------------------
          # General work
          #
          # Key rules for gr.basic_block in the Python gateway (GNURadio 3.10+):
          #   - Call self.consume(port, n)  to report input consumed.
          #   - Call self.produce(port, n)  to report output produced per port.
          #   - Return -2 (raw value of WORK_CALLED_PRODUCE) after calling produce().
          #     Do NOT use gr.WORK_CALLED_PRODUCE or self.WORK_CALLED_PRODUCE — both are
          #     broken in GNURadio 3.10's Python gateway (known bug, issue #7215).
          #   - ALL arguments to consume() and produce() MUST be plain Python int.
          #     Numpy integer subtypes will cause a pybind11 'Unable to cast' error.
          # ------------------------------------------------------------------
          def general_work(self, input_items, output_items):
              in0  = input_items[0]
              out0 = output_items[0]
              out1 = output_items[1]

              n_available = int(len(in0))
              if n_available == 0:
                  self.consume(0, 0)
                  self.produce(0, 0)
                  self.produce(1, 0)
                  return -2  # WORK_CALLED_PRODUCE (gr.WORK_CALLED_PRODUCE is broken in GNURadio 3.10 Python gateway)

              # How much space is available in each output buffer?
              out0_space = int(len(out0))
              out1_space = int(len(out1))

              # Retrieve all tags in the available input window and find sob offsets
              tags = self.get_tags_in_window(0, 0, n_available)
              sob_offsets = sorted([
                  int(tag.offset - self.nitems_read(0))
                  for tag in tags
                  if pmt.symbol_to_string(tag.key) == "squelch_sob"
              ])

              consumed  = 0   # input samples consumed this call
              produced0 = 0   # samples written to output[0]
              produced1 = 0   # samples written to output[1]
              sob_idx   = 0   # index into sob_offsets

              while consumed < n_available:

                  # Advance sob_idx past any tags behind current position
                  while sob_idx < len(sob_offsets) and sob_offsets[sob_idx] < consumed:
                      sob_idx += 1

                  next_sob = sob_offsets[sob_idx] if sob_idx < len(sob_offsets) else n_available

                  # ----------------------------------------------------------------
                  # Handle sob tag exactly at current position: trigger/reset switch
                  # ----------------------------------------------------------------
                  if next_sob == consumed:
                      self._switched = True
                      self._samples_remaining = int(self.Length)
                      sob_idx += 1
                      continue  # re-evaluate with updated state

                  # ----------------------------------------------------------------
                  # Switched state: route input -> output[1], output[0] gated
                  # ----------------------------------------------------------------
                  if self._switched:
                      limit = min(
                          out1_space - produced1,    # output[1] buffer space remaining
                          self._samples_remaining,    # how many samples left in burst
                          next_sob - consumed,        # stop before next sob tag
                          n_available - consumed      # available input
                      )

                      if limit <= 0:
                          break  # output[1] buffer full; yield to scheduler

                      out1[produced1:produced1 + limit] = in0[consumed:consumed + limit]

                      # Propagate tags to output[1]
                      for tag in tags:
                          rel = int(tag.offset - self.nitems_read(0))
                          if consumed <= rel < consumed + limit:
                              self.add_item_tag(
                                  1,
                                  int(self.nitems_written(1)) + produced1 + (rel - consumed),
                                  tag.key,
                                  tag.value,
                                  tag.srcid
                              )

                      produced1               += limit
                      consumed                += limit
                      self._samples_remaining -= limit

                      if self._samples_remaining <= 0:
                          # Burst complete: switch back to default
                          self._switched          = False
                          self._samples_remaining = 0

                  # ----------------------------------------------------------------
                  # Default state: route input -> output[0], output[1] gated
                  # ----------------------------------------------------------------
                  else:
                      limit = min(
                          out0_space - produced0,   # output[0] buffer space remaining
                          next_sob - consumed,       # stop before next sob tag
                          n_available - consumed     # available input
                      )

                      if limit <= 0:
                          break  # output[0] buffer full; yield to scheduler

                      out0[produced0:produced0 + limit] = in0[consumed:consumed + limit]

                      # Propagate tags to output[0]
                      for tag in tags:
                          rel = int(tag.offset - self.nitems_read(0))
                          if consumed <= rel < consumed + limit:
                              self.add_item_tag(
                                  0,
                                  int(self.nitems_written(0)) + produced0 + (rel - consumed),
                                  tag.key,
                                  tag.value,
                                  tag.srcid
                              )

                      produced0 += limit
                      consumed  += limit

              # Report consumption and production.
              # MUST use plain Python int — numpy integer subtypes cause pybind11 errors.
              self.consume(0, int(consumed))
              self.produce(0, int(produced0))
              self.produce(1, int(produced1))

              return -2  # WORK_CALLED_PRODUCE (gr.WORK_CALLED_PRODUCE is broken in GNURadio 3.10 Python gateway)
    comment: |-
      By default the input stream is forwarded to output stream [0] 
      and output stream [1] does not output any data.
      When on the floating input stream a Tag is received with the Key "squelch_sob"
      the IQ stream is diverted to output[1] for "Lenght" amount of samples.
      The objective is only to foward a part of a burst to output[1].
  states: {}
- name: note_0_0
  id: note
  parameters:
    note: Reference CLK
  states: {}
- name: note_0_0_0
  id: note
  parameters:
    note: Detection
  states: {}
- name: note_0_0_0_0
  id: note
  parameters:
    note: Visualisation
  states: {}
- name: note_0_0_1
  id: note
  parameters:
    note: Signal of interest
  states: {}
- name: qtgui_compass_1
  id: qtgui_compass
  parameters:
    fullNeedle: '1'
    gui_hint: qtgui_tab@0
    min_size: '250'
    name: Detected Phase difference
    update_time: '0.05'
  states: {}
- name: qtgui_const_sink_x_1
  id: qtgui_const_sink_x
  parameters:
    gui_hint: qtgui_tab@1
    name: '"Output: Constalation"'
    size: '1024'
    type: complex
    xmax: '1'
    xmin: '-1'
    ymax: '1'
    ymin: '-1'
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    gui_hint: qtgui_tab@0
    max: '4'
    min: '-4'
    name: '"Output: Phase difference"'
    type: float
    update_time: '0.05'
  states: {}
- name: qtgui_tab
  id: qtgui_tab_widget
  parameters:
    label0: Detected phase difference
    label1: debug
    num_tabs: '2'
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '16'
    interp: '1'
    type: fff
  states: {}
- name: virtual_sink_1_1_0_0
  id: virtual_sink
  parameters:
    stream_id: SigRef
  states: {}
- name: virtual_sink_1_1_0_0_0
  id: virtual_sink
  parameters:
    stream_id: SigInterest
  states: {}
- name: virtual_sink_1_1_0_0_0_0
  id: virtual_sink
  parameters:
    stream_id: DetectedPaseShift
  states: {}
- name: virtual_sink_1_1_0_0_1
  id: virtual_sink
  parameters:
    stream_id: Audio_probe
  states: {}
- name: virtual_source_0_0_0
  id: virtual_source
  parameters:
    stream_id: SigInterest
  states: {}
- name: virtual_source_0_0_0_0
  id: virtual_source
  parameters:
    stream_id: SigRef
  states: {}
- name: virtual_source_0_0_0_0_0
  id: virtual_source
  parameters:
    stream_id: SigRef
  states: {}
- name: virtual_source_0_0_0_0_0_0
  id: virtual_source
  parameters:
    stream_id: DetectedPaseShift
  states: {}
- name: virtual_source_0_0_0_0_1
  id: virtual_source
  parameters:
    stream_id: Audio_probe
  states: {}

connections:
- [analog_noise_source_x_0_0, '0', blocks_add_xx_0_0, '0']
- [analog_pwr_squelch_xx_0_0_0, '0', blocks_multiply_conjugate_cc_0, '1']
- [analog_pwr_squelch_xx_0_0_0, '0', virtual_sink_1_1_0_0_1, '0']
- [analog_sig_source_x_0_0_0, '0', blocks_throttle2_0_0, '0']
- [blocks_add_const_vxx_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [blocks_add_xx_0_0, '0', blocks_delay_0, '0']
- [blocks_complex_to_arg_0, '0', blocks_probe_rate_0, '0']
- [blocks_complex_to_arg_0, '0', blocks_tag_debug_0_0, '0']
- [blocks_complex_to_arg_0, '0', virtual_sink_1_1_0_0_0_0, '0']
- [blocks_complex_to_float_0, '0', rational_resampler_xxx_0, '0']
- [blocks_complex_to_float_0, '1', blocks_null_sink_0, '0']
- [blocks_delay_0, '0', virtual_sink_1_1_0_0_0, '0']
- [blocks_moving_average_xx_0_0, '0', blocks_complex_to_arg_0, '0']
- [blocks_moving_average_xx_0_0, '0', qtgui_const_sink_x_1, '0']
- [blocks_multiply_conjugate_cc_0, '0', epy_block_1, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_add_xx_0_0, '1']
- [blocks_multiply_const_vxx_0_0, '0', qtgui_compass_1, '0']
- [blocks_probe_rate_0, rate, blocks_message_debug_0, log]
- [blocks_throttle2_0_0, '0', virtual_sink_1_1_0_0, '0']
- [epy_block_0, '0', blocks_multiply_const_vxx_0, '0']
- [epy_block_1, '0', blocks_null_sink_0_2, '0']
- [epy_block_1, '1', blocks_moving_average_xx_0_0, '0']
- [rational_resampler_xxx_0, '0', audio_sink_0, '0']
- [virtual_source_0_0_0, '0', analog_pwr_squelch_xx_0_0_0, '0']
- [virtual_source_0_0_0_0, '0', epy_block_0, '0']
- [virtual_source_0_0_0_0_0, '0', blocks_multiply_conjugate_cc_0, '0']
- [virtual_source_0_0_0_0_0_0, '0', blocks_add_const_vxx_0, '0']
- [virtual_source_0_0_0_0_0_0, '0', qtgui_number_sink_0, '0']
- [virtual_source_0_0_0_0_1, '0', blocks_complex_to_float_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
